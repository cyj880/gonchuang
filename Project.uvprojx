# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: .\Start;.\Library;.\System;.\Hardware;.\Task;.\User;.\FreeRTOS\include;.\FreeRTOS\portable
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: core_cm4.h startup_stm32f427_437xx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h FreeRTOSConfig.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.c stm32f4xx_fmc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h
  group Hardware
    ./Hardware/: LED.c LED.h can.c can.h board.c board.h Emm_V5.c Emm_V5.h Servo.c Servo.h route_rx.c route_rx.h uart7.c uart7.h uart8.c uart8.h imu.c imu.h lunqu_imu.c lunqu_imu.h hwt101_imu.c hwt101_imu.h Buzzer.c Buzzer.h Key.c Key.h LCD.c LCD.h LCD_Data.c LCD_Data.h Encoder_RS485.c Encoder_RS485.h rdk_center.c rdk_center.h arm_m2006.c arm_m2006.h lift_zdt.c lift_zdt.h belt_zdt.c belt_zdt.h
  group Task
    ./Task/: led_task.c led_task.h servo_task.c servo_task.h key_task.c key_task.h motor_task.c ring_align.c ring_align.h motor_task.h lcd_task.c lcd_task.h odom_task.c odom_task.h pid.c pid.h
  group FreeRTOS
    ./FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ./FreeRTOS/portable/: port.c heap_4.c
